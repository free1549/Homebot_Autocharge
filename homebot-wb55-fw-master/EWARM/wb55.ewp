# IAR project wb55.ewp, settings and files
configuration wb55 (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RE ST STM32WB55RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: OPENTHREAD_CONFIG_FILE=<openthread_api_config_ftd.h>; USE_HAL_DRIVER; STM32WB55xx; TRACE_UART
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Utilities/lpm/tiny_lpm; ../tiny_lpm; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_WPAN; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../Middlewares/ST/STM32_WPAN/utilities; ../Middlewares/ST/STM32_WPAN/ble/core; ../Middlewares/ST/STM32_WPAN/ble/core/auto; ../Middlewares/ST/STM32_WPAN/ble/core/template; ../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Utilities/sequencer; ../Middlewares/ST/STM32_WPAN/ble; ../Drivers/CMSIS/Include; ../Src\Protobuffer; ../Src\Protobuffer\protobuf-c; ..\BSP\mmc; ..\BSP\Motor; ..\BSP\Remote; ..\BSP\Tof; ..\BSP\vl53l1\core; ..\BSP\vl53l1\platform; ..\BSP\X_NUCLEO_IKS01A1; ..\BSP\X-NUCLEO-53L0A1; ..\BSP; ..\BSP\Components\Common; ..\BSP\Components\vl53l0x; ..\BSP\Components\lsm6ds3; ../Drivers/STM32WBxx_HAL_Driver/Inc/protobuf-c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: wb55(server).bin
  ILINK.IlinkOutputFile: wb55.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Src/: Sensor.c
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User
    ../Src/: adc.c app_ble.c app_entry.c dma.c Fifo.c flash_if.c gpio.c hw_ipcc.c hw_timerserver.c i2c.c IR_Trace.c main.c p2p_client_app.c p2p_server_app.c rf.c rtc.c sequencer.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c tim.c tiny_lpm.c Trace_station.c UpdateFw.c usart.c usb.c
  group Application/User/Protobuffer
    ../Src/Protobuffer/: circular-buffer.cpp hi2st-parser.cpp simple.pb-c.c
  group Application/User/Protobuffer/protobuf-c
    ../Src/Protobuffer/protobuf-c/: protobuf-c.c
  group BSP
    ../BSP/: filter.c timer.c uart_trace.c
  group BSP/Components/LSM6DS3
    ../BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
  group BSP/Components/VL53L0X
    ../BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
  group BSP/Mmc
    ../BSP/mmc/: Customer.c main_sample.c MemsicNineAxisFusion-M4.a MMC3630KJ.c
  group BSP/Motor
    ../BSP/Motor/: encoders.c Motor.c
  group BSP/Tof
    ../BSP/Tof/: tof.c
    ../BSP/vl53l1/platform/: tof_vl53l1.c
  group BSP/vl53l1/core
    ../BSP/vl53l1/core/: VL53L1X_api.c VL53L1X_calibration.c
  group BSP/vl53l1/platform
    ../BSP/vl53l1/platform/: vl53l1_platform.c
  group BSP/X-NUCLEO-53L0A1
    ../BSP/X-NUCLEO-53L0A1/: vl53l0x_platform.c X-NUCLEO-53L0A1.c
  group BSP/X-NUCLEO-IKS01A1
    ../BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_pcd.c stm32wbxx_hal_pcd_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_adc.c stm32wbxx_ll_usb.c
  group Middlewares/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
    ../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
